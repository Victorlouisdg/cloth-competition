Commit message: update notebooks with new world

File: notebooks/motion_planning/table.urdf (robot description, URDF)
Before this commit: robot table, 2 links, 1 joints
Links:
- link box_link: geometry collision box size=1.5 2.0 0.1; visual box size=1.5 2.0 0.1
